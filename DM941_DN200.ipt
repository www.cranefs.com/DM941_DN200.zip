# Autodesk Inventor part: DM941_DN200
## iProperties
Created: 2011-01
Part Number: DM941_DN200
Document SubType Name: Modeling
Designer: D Cole
Density: 1 g/cm^3
Author: D Cole
